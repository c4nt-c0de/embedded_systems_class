# Keil uVision project demo.uvproj, settings and files
target Demo_01 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo
  c flags: Optim=1 uC99=1
  c include: .\Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./Source/: main.c pins.c utils.c component_helpers.c
  group Startup
    ./Libraries/: startup_stm32f10x_md_vl.s
  group Libraries
    ./Libraries/: core_cm3.c
